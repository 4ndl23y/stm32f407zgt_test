# Keil uVision project test1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test1
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=4 wLevel=2
  c include: .\inc;.\src;.\LCDlib;.\LCDlib\fonts;.\SDlib;.\SDlib\FatFs
  memory RVCT4: ROM 0x8008000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group inc
    ./inc/: main.h stm32f4xx.h
  group src
    ./src/: main.cpp
  group LCDlib
    ./LCDlib/: font.h lcd.h lcd.cpp
    ./LCDlib/fonts/: ub_font_arial_8x13.c ub_font_arial_10x15.c ub_font_arial_13x19.c ub_font_arial_11x18.c ub_font_arial_7x10.c ub_font_arial_14x22.c ub_font_arial_16x25.c
  group SDlib
    ./SDlib/: SD.cpp SD.h
software components: CMSIS:CORE 5.3.0, Device:Startup 2.6.3
